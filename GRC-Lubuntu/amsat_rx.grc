<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>amsat_rx</value></param>
<param><key>author</key><value>Handiko Gesang - YD1SDL - 2018</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Lapan A2 RX - Handiko Gesang</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>af_cut</value></param>
<param><key>value</key><value>3</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>label</key><value>AF Cutoff (kHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>(audio_rate/2)/1e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>AF Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>audio_out</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>label</key><value>Audio Mute</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>24e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_rate</value></param>
<param><key>value</key><value>192e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"/home/handiko/file_" + datetime.datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".wav"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>144.39e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>RF Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rtl_tune</value></param>
<param><key>value</key><value>int(freq / 100e3) * 100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>int(freq)</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
<param><key>label</key><value>Center Freq (Hz), (doppler corrected)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>0.01</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>bb_rate/(2*math.pi*40e3/8.0)</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>int(audio_rate)</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>open</key><value>audio_out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_rotator_cc</key>
<param><key>id</key><value>blocks_rotator_cc_0</value></param>
<param><key>phase_inc</key><value>((rtl_tune - freq) / samp_rate) * 2 * math.pi</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>/home/handiko/file.wav</value></param>
<param><key>samp_rate</key><value>int(audio_rate)</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,98e3,10e3,firdes.WIN_BLACKMAN)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1,bb_rate,10e3,1e3,firdes.WIN_BLACKMAN)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_2</value></param>
<param><key>decim</key><value>int(bb_rate/audio_rate)</value></param>
<param><key>taps</key><value>firdes.low_pass(pow(10,af_gain/10),bb_rate,af_cut*1e3,audio_rate/8,firdes.WIN_BLACKMAN)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>gpredict_port</key><value>4532</value></param>
<param><key>target</key><value>freq</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import datetime</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>58</value></param>
<param><key>freq0</key><value>rtl_tune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>tab@0:0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.7</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>bb_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>tab@1:0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.7</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tab@0:1,0,1,1</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-90</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>bb_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>tab@1:1,0,1,1</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-90</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate)</value></param>
<param><key>interp</key><value>192000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>label0</key><value>Input Spectrum</value></param>
<param><key>label1</key><value>Baseband</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>in_spec</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>bb_spec</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>in_spec</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>bb_spec</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>fft_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rotator_cc_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_2</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_2</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_rotator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
