<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>aprs_minigate</value></param>
<param><key>author</key><value>Handiko Gesang - YD1SDL - 2018</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>APRS I-Gate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>RF Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>49</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.2e6</value></param>
</block>
<block>
<key>DL1KSV_AFSK_1200baud_demod</key>
<param><key>id</key><value>DL1KSV_AFSK_1200baud_demod_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>RTL_APRS_RX</key>
<param><key>id</key><value>RTL_APRS_RX_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>device_ppm</key><value>58</value></param>
<param><key>freq</key><value>144.39e6</value></param>
<param><key>rf_gain</key><value>rfgain</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>afsk_aprs2inet</key>
<param><key>id</key><value>afsk_aprs2inet_1</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sample_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.band_pass(10,48e3,1e3,2400,1e2,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>igate_aprs_demod</key>
<param><key>id</key><value>igate_aprs_demod_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>igate_aprs_is_sink</key>
<param><key>id</key><value>igate_aprs_is_sink_0</value></param>
<param><key>callsign</key><value>YD1SDL-10</value></param>
<param><key>host</key><value>rotate.aprs.net</value></param>
<param><key>password</key><value>24505</value></param>
<param><key>port</key><value>14580</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>info</key><value>!0615.52S/10643.56E`PHG5130/GNU Radio APRS I-gate - ver 0</value></param>
<param><key>interval</key><value>120</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>info</key><value>&gt;Non Permanent - Experimental</value></param>
<param><key>interval</key><value>300</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0_0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APRS</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>info</key><value>=0735.52SY11027.48E#PHG5850/DIGI Balerante Lab. SSTK. UGM</value></param>
<param><key>interval</key><value>70</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YB2YOU-1</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0_1</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>info</key><value>:YB2YOU-1 :Hallo Balerante{001</value></param>
<param><key>interval</key><value>1800</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0_1_0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>info</key><value>:EMAIL    :handikogesang@gmail.com This is a test</value></param>
<param><key>interval</key><value>185</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0_1_0_0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>info</key><value>:YC2UPT   : {001</value></param>
<param><key>interval</key><value>1800</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<block>
<key>igate_debug_print_msg</key>
<param><key>id</key><value>igate_debug_print_msg_0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>bw</key><value>192e3</value></param>
<param><key>fc</key><value>144.39e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.8</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>afsk</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>afsk</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>afsk</value></param>
</block>
<connection><source_block_id>DL1KSV_AFSK_1200baud_demod_0</source_block_id><sink_block_id>afsk_aprs2inet_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RTL_APRS_RX_0</source_block_id><sink_block_id>fft_filter_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RTL_APRS_RX_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>afsk_aprs2inet_1</source_block_id><sink_block_id>show_text_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_3</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>igate_aprs_demod_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_demod_0</source_block_id><sink_block_id>igate_debug_print_msg_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0</source_block_id><sink_block_id>igate_debug_print_msg_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0</source_block_id><sink_block_id>igate_debug_print_msg_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0_0</source_block_id><sink_block_id>igate_debug_print_msg_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0_1</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0_1_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0_1_0_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>DL1KSV_AFSK_1200baud_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>igate_aprs_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
