<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>aprs_symbol_recov</value></param>
<param><key>author</key><value>Handiko Gesang - YD1SDL - 2018</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>APRS Symbol Recovery</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>afgain</value></param>
<param><key>value</key><value>-7</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>AF Gain (dB)</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>afsk_spec</value></param>
<param><key>value</key><value>[1200, 1200, 2200]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_decim</value></param>
<param><key>value</key><value>int(bb_rate)/int(ch_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_rate</value></param>
<param><key>value</key><value>192e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_ppm</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>144.39e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>0.175</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>in_sps</value></param>
<param><key>value</key><value>int(ch_rate) / afsk_spec[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>RF Gain (dB)</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>49</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.88e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>thresh</value></param>
<param><key>value</key><value>-50*2</value></param>
</block>
<block>
<key>afsk_afsk1200</key>
<param><key>id</key><value>afsk_afsk1200_0</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>sample_rate</key><value>int(ch_rate)</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>thresh</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>ch_rate/(2*math.pi*12e3/8.0)</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>gain_omega</key><value>0.25*gain_mu*gain_mu</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>out_sps*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>32</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>bb_decim</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>firdes.low_pass(1,bb_rate,ch_rate/2,ch_rate/4,firdes.WIN_BLACKMAN)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.band_pass(1,ch_rate,400,5e3,400,firdes.WIN_BLACKMAN)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fsk_demod</key>
<param><key>id</key><value>fsk_demod_0</value></param>
<param><key>baud</key><value>afsk_spec[0]</value></param>
<param><key>fsk_hi_tone</key><value>afsk_spec[2]</value></param>
<param><key>fsk_lo_tone</key><value>afsk_spec[1]</value></param>
<param><key>in_sps</key><value>in_sps</value></param>
<param><key>out_sps</key><value>out_sps</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>hdlc_to_ax25</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import os, pty
import struct

import pmt
import numpy as np
from gnuradio import gr

import packet


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """
    Converts an array of bytes into a AX25Packet object.

    Connect to the "HDLC Deframer", or a block which emits a PMT tuple of
    (None, bytearray)
    """
    def __init__(self):
        gr.sync_block.__init__(self,
                               name="HDLC to AX.25",
                               in_sig=None,
                               out_sig=None)
        self.message_port_register_in(pmt.intern('hdlc in'))
        self.message_port_register_out(pmt.intern('ax25 out'))
        self.set_msg_handler(pmt.intern('hdlc in'), self.handle_msg)

    def handle_msg(self, msg_pmt):
        msg_pmt = pmt.pmt_to_python.pmt_to_python(msg_pmt)

        msg = bytearray(msg_pmt[1])

        try:
            pkt = packet.from_bytes(msg)
            self.message_port_pub(pmt.intern('ax25 out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in (packet.dump(pkt) + '\n')], np.uint8))))
                
        except ValueError as e:
            print e

    def stop(self):
        gr.sync_block.stop(self)
        
    def work(self, input_items, output_items):
        in0 = input_items[0]
        # &lt;+signal processing here+&gt;
        return len(input_items[0])
        
        
        
</value></param>
<param><key>comment</key><value>Pyhton module which required 
to run this script (packet.py)
needed to be copied to the 
/usr/lib/python2.7 dir</value></param>
</block>
<block>
<key>igate_aprs_demod</key>
<param><key>id</key><value>igate_aprs_demod_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>igate_aprs_is_sink</key>
<param><key>id</key><value>igate_aprs_is_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>callsign</key><value>YD1SDL-10</value></param>
<param><key>host</key><value>rotate.aprs2.net</value></param>
<param><key>password</key><value>24505</value></param>
<param><key>port</key><value>14580</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>info</key><value>!0745.80S/11022.51E`PHG5130/GNU Radio APRS I-gate - ver 0</value></param>
<param><key>interval</key><value>180</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>info</key><value>:BLNA     :New Digi YB2YOU-1 at Mt. Merapi is now in full operational</value></param>
<param><key>interval</key><value>3600</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<block>
<key>igate_debug_print_msg</key>
<param><key>id</key><value>igate_debug_print_msg_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>dev_ppm</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>packet</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph

from datetime import datetime
import struct

'''
A library of functions and objects for manipulating AX.25 packets.
At the moment, it was mostly designed to handle APRS UI frames, so
further functionality has not been tested.
'''

class AX25Address(object):
    '''
    An object representing an AX.25 address. You can print this object to
    the screen, or cast it to a string.

    If the SSID is zero, the callsign will print as 'XXdYYY'. Otherwise,
    the SSID will appear as '-%d' at the end.
    '''
    def __init__(self):
        self.callsign = None
        self.ssid = None
        self.ch_bit = None
        self.reserved = None

    def __str__(self):
        if self.ssid == 0:
            return self.callsign
        else:
            return '%s-%d' % (self.callsign, self.ssid)

    def __repr__(self):
        return '&lt;AX25Address(callsign=%s, ssid=%d)&gt;' % (self.callsign,
                self.ssid)

    def to_bytes(self, last_addr=False, ch_bit=None):
        if (
                self.callsign is None
                or not isinstance(self.ssid, int)
           ):
            raise ValueError("Address fields not populated!")

        # Pad callsign with spaces to 6 chars
        padded_cs = '%-6s' % self.callsign

        array = bytearray([ord(c) &lt;&lt; 1 for c in padded_cs])

        last_byte = self.ssid &lt;&lt; 1

        if last_addr:
            last_byte |= 1

        if (ch_bit is None and self.ch_bit) or ch_bit:
            last_byte |= 0x80

        array.append(last_byte)
        return array

class AX25Packet(object):
    '''
    An object representing an AX.25 packet.
    '''
    def __init__(self):
        self.dest = None
        self.src = None
        self.digipeaters = []
        self.control = None
        self.frame_type = None
        self.recv_seq = None
        self.pf_bit = None
        self.send_seq = None
        self.supervisory_bits = None
        self.unnumbered_fm_bits = None
        self.protocol_id = None
        self.info = None
        self.timestamp = datetime.now()

    def __repr__(self):
        return '&lt;AX25Packet(src=%s, dest=%s, frame_type=%s, len=%d)&gt;' % \
                (self.src, self.dest, self.frame_type, len(self.info))

    def to_bytes(self):
        array = bytearray()
        array += self.dest.to_bytes()
        array += self.src.to_bytes(last_addr=(len(self.digipeaters) == 0))
        
        for i, dptr in enumerate(self.digipeaters):
            array += dptr.to_bytes(last_addr=(len(self.digipeaters) == (i+1)))

        # TODO: Handle various build conditions
        array += bytearray([self.control, self.protocol_id])
        array += bytearray(self.info)

        return array

    def kiss_wrap(self):
        return kiss_wrap_bytes(self.to_bytes())

    def checksum(self):
        ''' With thanks to W6KWF's excellent whitepaper '''
        crc = 0xffff

        for byte in self.to_bytes():
            # Byte to bits: bin returns 0bXXXXXXX
            bits = bin(byte)[2:].zfill(8)

            # Walk through bits (as string) backwards
            for i in xrange(7, -1, -1):
                bit = 1 if bits[i] == '1' else 0
                if (crc &amp; 0x0001) != bit:
                    crc = (crc &gt;&gt; 1) ^ 0x8408
                else:
                    crc = crc &gt;&gt; 1

        return bytearray(struct.pack('&lt;H', (crc ^ 0xffff)))

    def hdlc_wrap(self, preamble_count=1, trailer_count=1):
        out = ''
        pkt = self.to_bytes()
        csum = self.checksum()

        # Bytes to bits (LSB first)
        for byte in (pkt + csum):
            # bin() outputs 0bxxxxx, msb first
            # - strip off the 0b (using [2:])
            # - zero pad out to 8 bits (using .zfill)
            # - reverse string to be LSB first (with [::-1])
            out += bin(byte)[2:].zfill(8)[::-1]

        # Bit stuffing
        unstuffed = out
        stuffed = ''
        
        one_count = 0
        for bit in unstuffed:
            stuffed += bit

            # Keep a count of the number of subsequent 1's in a row
            if bit == '1':
                one_count += 1
            else:
                one_count = 0

            # If we hit 5 1's in a row, stuff a bit, and clear the counter
            if one_count == 5:
                stuffed += '0'
                one_count = 0

        out = stuffed

        # Preamble
        out = ('1111110' * preamble_count) + out
        out += ('0111111' * trailer_count)

        # Invert data, differentially encode
        out = [1 if c == '0' else 0 for c in out]
        for i in xrange(1, len(out) - 1):
            out[i] = out[i] ^ out[i-1]

        return out

def kiss_wrap_bytes(array):
    out = bytearray()
    out.append(0xc0)
    out.append(0x00)
    
    for bite in array:
        if bite == 0xc0:
            out.append(0xdb)
            out.append(0xdc)
        elif bite == 0xdb:
            out.append(0xdb)
            out.append(0xdd)
        else:
            out.append(bite)

    out.append(0xc0)

    return out

def bytes_to_address(array):
    ''' Converts an array of 7 bytes into an AX25Address object '''
    addr = AX25Address()
    addr.callsign = ''.join([chr(d &gt;&gt; 1) for d in array[0:6]]).strip()
    addr.ssid = (array[6] &gt;&gt; 1) &amp; 0x0f
    addr.reserved = (array[6] &gt;&gt; 5) &amp; 0x03
    addr.ch_bit = (array[6] &gt;&gt; 7) &amp; 0x01

    last = True if (array[6] &amp; 0x01) else False
    
    return (last, addr)

def string_to_address(string):
    ''' Converts a string (like "KB3VOZ -2") into an Address object '''
    if '-' in string:
        try:
            (cs, ssid) = string.split('-')
            ssid = int(ssid)
        except ValueError:
            raise ValueError("Bad callsign format")
    else:
        cs = string
        ssid = 0

    if len(cs) == 0 or len(cs) &gt; 6 or ssid &lt; 0 or ssid &gt; 16:
        raise ValueError("Bad callsign format")

    ret = AX25Address()
    ret.callsign = cs
    ret.ssid = ssid
    
    return ret
 

def from_bytes(array, extended=False):
    '''
    Builds an AX25Packet from a bytearray.

    modulo 128 extended packets are not yet implemented.
    '''
    if not isinstance(array, bytearray):
        raise TypeError("Function takes bytearray")

    if len(array) &lt; 15:
        raise ValueError("Packet is too short to process")

    packet = AX25Packet()

    # Pull out the destination and source from the packet
    (last, packet.dest) = bytes_to_address(array[0:7])
    if(last):
        raise ValueError("Unexpected stop of address section")
    (last, packet.src) = bytes_to_address(array[7:14])

    # Pull out each repeater
    offset = 2 * 7
    while not last:
        addr = array[offset:offset+7]

        # TODO: AX.25 spec only allows for 2 repeaters, not 8. But,
        #       APRS allows for up to 8 repeaters. Resolve?
        if len(addr) != 7 or len(packet.digipeaters) &gt;= 8:
            raise ValueError("Address section not terminated")

        (last, addr) = bytes_to_address(addr)
        packet.digipeaters.append(addr)
        offset += 7

    if offset &gt;= len(array):
        raise ValueError("Not enough bytes left for control")

    if not extended:
        packet.control = array[offset]
        offset += 1

        # We'll pull these fields here, but not all frames contain
        # this information. 
        packet.recv_seq = packet.control &gt;&gt; 5
        packet.pf_bit = (packet.control &amp; 0x10) == 0x10
        packet.send_seq = (packet.control &amp; 0x0c) &gt;&gt; 2

        # Determine the frame type, and fill / clear additonal fields
        if (packet.control &amp; 0x01) == 0x00:
            packet.frame_type = 'I'
        elif (packet.control &amp; 0x03) == 0x01:
            packet.frame_type = 'S'
            packet.supervisory_bits = packet.send_seq
            packet.send_seq = None
        elif (packet.control &amp; 0x03) == 0x03:
            packet.recv_seq = None
            packet.send_seq = None
            packet.unnumbered_fm_bits = (packet.control &amp; 0xec)

            if packet.unnumbered_fm_bits == 0:
                packet.frame_type = 'UI'
            else:
                packet.frame_type = 'U'
        else:
            raise ValueError("Invlid frame type!")

    else:
        raise NotImplementedError("Extended control field not implemented yet!")

    # I and UI frames contain the protocol ID byte 
    # (ie: first byte of info segment)
    if packet.frame_type in ['I', 'UI']:
        if offset &gt;= len(array):
            raise ValueError("Not enough bytes left for protocol_id")

        packet.protocol_id = array[offset]
        offset += 1

    # The rest of the buffer is info now.
    packet.info = array[offset:]

    return packet
    
def dump(packet):
    '''
    Returns a string representing the packet in TNC-2 format

    Format:
        SRC&gt;DEST,RPT1,RPT2:INFO
    '''

    ret = '%s&gt;%s' % (packet.src, packet.dest)

    for station in packet.digipeaters:
        ret += ',%s' % station

    ret += ':%s' % packet.info

    return ret
</value></param>
<param><key>comment</key><value>The pyhton module generated
from this block (packet.py) needed
to be copied to /lib/python2 dir</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>int(samp_rate / bb_rate)</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0_0</value></param>
<param><key>decim</key><value>int(samp_rate / ch_rate)</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>bw</key><value>192e3</value></param>
<param><key>fc</key><value>144.39e6</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.8</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-10</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>width1</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1200</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>4.2</value></param>
<param><key>ymin</key><value>-4.2</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>bw</key><value>192e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-105</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_0</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_2</value></param>
<param><key>gui_hint</key><value>2,2,2,1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>symbol</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>afsk</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>symbol</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>afsk</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>afsk</value></param>
</block>
<connection><source_block_id>afsk_afsk1200_0</source_block_id><sink_block_id>show_text_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_and_const_xx_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0</source_block_id><sink_block_id>blocks_and_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>show_text_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>blocks_not_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>hdlc_to_ax25</sink_block_id><source_key>out</source_key><sink_key>hdlc in</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>fsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fsk_demod_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hdlc_to_ax25</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>ax25 out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hdlc_to_ax25</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>ax25 out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>igate_aprs_demod_0</source_block_id><sink_block_id>igate_aprs_is_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_demod_0</source_block_id><sink_block_id>igate_debug_print_msg_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0</source_block_id><sink_block_id>igate_aprs_is_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0_1_0_0</source_block_id><sink_block_id>igate_aprs_is_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>pfb_decimator_ccf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>afsk_afsk1200_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>igate_aprs_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
