<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>APRS</value></param>
<param><key>author</key><value>dl1ksv</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Receives ax.25 packets , display the packets, and converts aprs packet to be send via tcp/ip</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receives ax.25/ aprs packets</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Attack</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Decay</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>afgain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>AF Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>afsk_aprs2inet</key>
<param><key>id</key><value>afsk_aprs2inet_0</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>sample_rate</key><value>samp_rate/3</value></param>
</block>
<block>
<key>afsk_ax25decode</key>
<param><key>id</key><value>afsk_ax25decode_1</value></param>
<param><key>debug_level</key><value>4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sample_rate</key><value>8000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>decim</key><value>3</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>pow(10,afgain/10)</value></param>
<param><key>high_cutoff_freq</key><value>2450</value></param>
<param><key>low_cutoff_freq</key><value>950</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>server</key><value>True</value></param>
<param><key>port</key><value>8000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>detectMarkSpace</key>
<param><key>id</key><value>detectMarkSpace_0_0</value></param>
<param><key>attack</key><value>Attack</value></param>
<param><key>decay</key><value>Decay</value></param>
<param><key>Frequency</key><value>1200</value></param>
<param><key>samp_rate</key><value>8000</value></param>
</block>
<block>
<key>detectMarkSpace</key>
<param><key>id</key><value>detectMarkSpace_1_0</value></param>
<param><key>attack</key><value>Attack</value></param>
<param><key>decay</key><value>Decay</value></param>
<param><key>Frequency</key><value>2200</value></param>
<param><key>samp_rate</key><value>8000</value></param>
</block>
<block>
<key>show_text</key>
<param><key>id</key><value>show_text_0_0_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
</block>
<connection><source_block_id>afsk_aprs2inet_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>afsk_aprs2inet_0</source_block_id><sink_block_id>show_text_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>afsk_ax25decode_1</source_block_id><sink_block_id>show_text_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>detectMarkSpace_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>detectMarkSpace_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_0_0</source_block_id><sink_block_id>afsk_aprs2inet_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_0_0</source_block_id><sink_block_id>afsk_ax25decode_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detectMarkSpace_0_0</source_block_id><sink_block_id>blocks_sub_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>detectMarkSpace_1_0</source_block_id><sink_block_id>blocks_sub_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
