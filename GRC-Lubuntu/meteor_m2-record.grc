<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>meteor_m2_record</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baudrate</value></param>
<param><key>value</key><value>72000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_rate</value></param>
<param><key>value</key><value>samp_rate/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_rate</value></param>
<param><key>value</key><value>baudrate*2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"METEOR_M2_" + str(bb_rate) + "_20_04_2018.cfile"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmu</value></param>
<param><key>value</key><value>0.002</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>value</key><value>45</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>49</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.88e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(ch_rate) / baudrate</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>10e-3</value></param>
<param><key>reference</key><value>0.25</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>gmu</value></param>
<param><key>gain_omega</key><value>0.25*gmu*gmu</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>(ch_rate/baudrate)*(1+0.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>6.28/400</value></param>
<param><key>modulus</key><value>1.0</value></param>
<param><key>num_taps</key><value>16</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>6.28/200</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>55</value></param>
<param><key>freq0</key><value>137.9e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>3</value></param>
<param><key>xmin</key><value>-3</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>bb_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>bb_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(bb_rate)</value></param>
<param><key>interp</key><value>int(ch_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.7</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>32*sps</value></param>
<param><key>samp_rate</key><value>sps*1.0</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
