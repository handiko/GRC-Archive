<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fake_igate</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>igate_aprs_is_sink</key>
<param><key>id</key><value>igate_aprs_is_sink_0</value></param>
<param><key>callsign</key><value>YD1SDL-10</value></param>
<param><key>host</key><value>rotate.aprs.net</value></param>
<param><key>password</key><value>24505</value></param>
<param><key>port</key><value>14580</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APOT21</value></param>
<param><key>info</key><value>&gt; -10C Celebrating 2 Years Anniversary LAPAN-A2/IO 86 Sat</value></param>
<param><key>interval</key><value>61</value></param>
<param><key>path</key><value>SGATE</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YB0X-1</value></param>
</block>
<block>
<key>igate_aprs_pkt_gen</key>
<param><key>id</key><value>igate_aprs_pkt_gen_0_0</value></param>
<param><key>ctrl</key><value>3</value></param>
<param><key>dst</key><value>APGRC</value></param>
<param><key>info</key><value>!0745.80S/11022.51E` Temporary / Experimental APRS I/S-Gate</value></param>
<param><key>interval</key><value>35</value></param>
<param><key>path</key><value>WIDE2-2</value></param>
<param><key>pid</key><value>240</value></param>
<param><key>src</key><value>YD1SDL-10</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>igate_aprs_pkt_gen_0_0</source_block_id><sink_block_id>igate_aprs_is_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
