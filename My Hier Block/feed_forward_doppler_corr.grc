<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>feed_forward_doppler_corr</value></param>
<param><key>category</key><value>My Hier Block</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Feed Forward Doppler Corr.</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>2*math.pi</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>integration_sample</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/integration_sample</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1.0*corr_gain*samp_rate*0.025183</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_1</value></param>
<param><key>amplitude</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>corr_gain</value></param>
<param><key>label</key><value>Correction Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_bw</value></param>
<param><key>label</key><value>Doppler Bandwidth (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,doppler_bw/2,doppler_bw/20,firdes.WIN_BLACKMAN)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>integration_sample</value></param>
<param><key>label</key><value>Integration Sample Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>selected</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>carrier</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>error</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>192e3</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_vco_c_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vco_c_1</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
